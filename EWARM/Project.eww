<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Temperature_and_CO2_to_display.ewp</path>
  </project>
  <batchBuild />
</workspace>

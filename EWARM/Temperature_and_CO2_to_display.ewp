# IAR project Temperature_and_CO2_to_display.ewp, settings and files
configuration Temperature_and_CO2_to_display (ARM, debug)
  General.OGChipSelectEditMenu: STM32L431KB ST STM32L431KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L431xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Temperature_and_CO2_to_display.hex
  ILINK.IlinkOutputFile: Temperature_and_CO2_to_display.out
  ILINK.IlinkIcfFile: stm32l431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: CCS811.c main.c spi_ili9341.c stm32l4xx_hal_msp.c stm32l4xx_it.c
    ../Core/Inc/: CCS811.h spi_ili9341.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c

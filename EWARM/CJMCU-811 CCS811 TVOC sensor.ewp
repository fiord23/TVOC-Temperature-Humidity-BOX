# IAR project CJMCU-811 CCS811 TVOC sensor.ewp, settings and files
configuration CJMCU-811 CCS811 TVOC sensor (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CJMCU-811 CCS811 TVOC sensor.hex
  ILINK.IlinkOutputFile: CJMCU-811 CCS811 TVOC sensor.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/User/Core/AHT10
    ../Core/Src/: AHT10.c
    ../Core/Inc/: AHT10.h
  group Application/User/Core/BMP280
    ../Core/Src/: BMP280.c
    ../Core/Inc/: BMP280.h
  group Application/User/Core/CCS811
    ../Core/Src/: CCS811.c
    ../Core/Inc/: CCS811.h
  group Application/User/Core/DISPLAY
    ../Core/Src/: spi_ili9341.c
    ../Core/Inc/: spi_ili9341.h
  group Application/User/Core/Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/Core/Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Application/User/Core/HTU21D
    ../Core/Src/: HTU21D.c
    ../Core/Inc/: HTU21D.h
  group Application/User/Core/I2C1
    ../Core/Src/: I2C1.c
    ../Core/Inc/: I2C1.h
